Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-07-06T08:36:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 06 08:36:22 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f102c66e-3cdb-44a3-9368-d284c09f13c7\73ae80b4-5d8e-4b93-9d7d-33d73b22afa7\ifc * Database version: 5507 * Database creation date: Thu Jul 06 08:36:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 06 08:36:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 06 08:36:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12298850_USA_HR1422-3_EDST-CLST:25142281_USA_12298850_HR1422-3_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 25142281_USA_12298850_HR1422-3_EDST-CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 25142281_USA_12298850_HR1422-3_EDST-CLST
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_359598
Description: Flow; FlowDirection: SOURCEANDSINK
